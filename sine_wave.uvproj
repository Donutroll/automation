# Keil uVision project sine_wave.uvproj, settings and files
target QVGA Base Board (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: sine_wave
  c flags: Optim=1 wLevel=2
  asm misc: --diag_suppress 1608,6314
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --first=LPC2400.o(RESET) --bestdebug --arm_only
  group Startup
    ./src/: LPC2400.s
  group Source Code
    ./src/: main.c sine_wave_data.c automation.c delay.c timer.c profile.h automation.h drawTime.c drawTime.h
  group lcd
    ./lcd/: font_macro.h font5x7.c font5x7.h lcd_cfg.h lcd_grph.c lcd_grph.h lcd_hw.c lcd_hw.h lpc24xx.h sdram.c sdram.h
